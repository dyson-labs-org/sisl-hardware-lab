options:
  parameters:
    generate_options: qt_gui
    id: spreadtest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2.39e9
  states: {}
- name: code_len
  id: variable
  parameters:
    value: '127'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: code_len * sps_chip
  states: {}
- name: sps_chip
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Raw Spread Waveform"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0_0, '0']
- [soapy_hackrf_source_0, '0', blocks_complex_to_real_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
